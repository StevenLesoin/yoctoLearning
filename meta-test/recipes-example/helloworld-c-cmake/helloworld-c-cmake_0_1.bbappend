SRC_URI += "file://001-helloWorldC-add-cmake.patch;patchdir=${WORKDIR}/git"

