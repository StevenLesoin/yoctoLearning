SRC_URI += "file://001-helloWorldC-add-autotools.patch;patchdir=${WORKDIR}/git"

